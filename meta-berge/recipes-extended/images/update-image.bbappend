FILESEXTRAPATHS:prepend := "${THISDIR}/update-image/rpi:"

SRC_URI += "file://sw-description file://emmcsetup.lua"
