FILESEXTRAPATHS:prepend := "${THISDIR}/linux-raspberrypi:"

SRC_URI += "file://enable-overlayfs.cfg"
